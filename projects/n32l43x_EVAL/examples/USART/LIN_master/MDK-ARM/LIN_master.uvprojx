# Keil uVision project LIN_master.uvprojx, settings and files
target N32L43x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L436MB Nationstech
  pack: Nationstech.N32L43x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LIN_master +hex
  AfterMake: fromelf --bin --output=.\bin\LIN_master.bin .\Objects\LIN_master.axf
  AfterMake: fromelf --vhx -d --32x1 .\Objects\LIN_master.axf --output=.\bin\LIN_master.dua
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L43X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32l43x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l43x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l43x.c
  group FWLB
    ../../../../../../firmware/n32l43x_std_periph_driver/src/: n32l43x_gpio.c n32l43x_rcc.c n32l43x_usart.c misc.c
  group USER
    ../src/: main.c lin_master.c delay.c n32l43x_it.c
    ../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
