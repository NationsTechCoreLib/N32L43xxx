# IAR project SPI_DEVICE_REGISTER.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32L436MB Nations N32L436MB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L43X; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa084
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\firmware\CMSIS\core; ..\..\..\..\..\..\firmware\CMSIS\device; ..\..\..\..\..\..\middlewares\rt-thread\include; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\drivers; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include\ipc; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\include; ..\..\DeviceDrivers\gpio\inc; ..\..\DeviceDrivers\uart\inc; ..\inc; ..\..\..\..\..\..\firmware\n32l43x_std_periph_driver\inc; ..\..\DeviceDrivers\spi\inc; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\spi; ..\..\..\..\..\..\middlewares\rt-thread\components\drivers\spi\sfud\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_DEVICE_REGISTER.hex
  ILINK.IlinkOutputFile: SPI_DEVICE_REGISTER.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l43x.c
  group CORTEX-M4
    ../../../../../../middlewares/rt-thread/libcpu/cortex-m4/: context_iar.S cpuport.c
  group Device_Drivers
    ../../DeviceDrivers/gpio/src/: drv_gpio.c
    ../../DeviceDrivers/spi/src/: drv_spi.c
    ../../DeviceDrivers/uart/src/: drv_usart.c
  group DOC
    ../: readme.txt
  group Drivers
    ../../../../../../middlewares/rt-thread/components/drivers/src/: completion.c
    ../../../../../../middlewares/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../middlewares/rt-thread/components/drivers/serial/: serial.c
    ../../../../../../middlewares/rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../../../../middlewares/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group FWLB
    ../../../../../../firmware/n32l43x_std_periph_driver/src/: misc.c n32l43x_exti.c n32l43x_gpio.c n32l43x_rcc.c n32l43x_spi.c n32l43x_usart.c
  group RT-Thread
    ../../../../../../middlewares/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l43x_EWARM.s
  group USER
    ../src/: board.c main.c n32l43x_it.c spi_flash_w25q.c
