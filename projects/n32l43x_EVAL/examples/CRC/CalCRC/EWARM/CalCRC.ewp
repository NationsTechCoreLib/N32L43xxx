# IAR project CalCRC.ewp, settings and files
configuration N32L43x (ARM, debug)
  General.OGChipSelectEditMenu: N32L436RB Nations N32L436RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L43X; _DLIB_FILE_DESCRIPTOR; __IAR_ARM; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32l43x_std_periph_driver/inc; ..\..\..\..\bsp\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CalCRC.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Nations\N32L43x\N32L436xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l43x.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32l43x_std_periph_driver/src/: misc.c n32l43x_adc.c n32l43x_can.c n32l43x_crc.c n32l43x_dac.c n32l43x_dbg.c n32l43x_dma.c n32l43x_exti.c n32l43x_flash.c n32l43x_gpio.c n32l43x_i2c.c n32l43x_iwdg.c n32l43x_opamp.c n32l43x_pwr.c n32l43x_rcc.c n32l43x_rtc.c n32l43x_spi.c n32l43x_tim.c n32l43x_usart.c n32l43x_wwdg.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l43x_EWARM.s
  group USER
    ../src/: main.c n32l43x_it.c
