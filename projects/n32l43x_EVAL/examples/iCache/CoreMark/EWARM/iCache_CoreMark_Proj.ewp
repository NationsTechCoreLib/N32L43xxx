# IAR project iCache_CoreMark_Proj.ewp, settings and files
configuration N32L43x (ARM, debug)
  General.OGChipSelectEditMenu: N32L436MB Nations N32L436MB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L43X; _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; SYSCLK_SRC=SYSCLK_USE_HSE_PLL; SYSCLK_FREQ=108000000
  ICCARM.CCIncludePath2: ../inc; ../coremark; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/n32l43x_std_periph_driver/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: iCache_CoreMark_Proj.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l43x.c
  group COREMARK
    ../coremark/: core_list_join.c core_main.c core_matrix.c core_portme.c core_state.c core_util.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32l43x_std_periph_driver/src/: misc.c n32l43x_crc.c n32l43x_flash.c n32l43x_gpio.c n32l43x_rcc.c n32l43x_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l43x_EWARM.s
  group USER
    ../src/: main.c n32l43x_it.c
