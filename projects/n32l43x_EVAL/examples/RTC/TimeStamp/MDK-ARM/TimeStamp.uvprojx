# Keil uVision project TimeStamp.uvprojx, settings and files
target N32L43x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L436MB Nationstech
  pack: Nationstech.N32L43x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TimeStamp +hex
  AfterMake: fromelf --bin --output=.\bin\TimeStamp.bin .\Objects\TimeStamp.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L43X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\n32l43x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l43x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l43x.c
  group USER
    ../src/: main.c n32l43x_it.c User_LED_Config.c User_RTC_Config.c User_Systick_Config.c User_RTCBKP_Config.c User_Delay_Config.c
  group DOC
    ../: readme.txt
  group FWLB
    ../../../../../../firmware/n32l43x_std_periph_driver/src/: misc.c n32l43x_exti.c n32l43x_flash.c n32l43x_gpio.c n32l43x_pwr.c n32l43x_rcc.c n32l43x_rtc.c n32l43x_usart.c
  group LOG
    ../../../../bsp/src/: log.c
