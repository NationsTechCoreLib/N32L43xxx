# IAR project ALGO_Demo.ewp, settings and files
configuration N32L43x (ARM, debug)
  General.OGChipSelectEditMenu: N32L436MB Nations N32L436MB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32L43X; _DLIB_FILE_DESCRIPTOR; USE_STDPERIPH_DRIVER; __IAR_ARM
  ICCARM.CCIncludePath2: ../inc; ../../../../../../firmware/CMSIS/core; ../../../../../../firmware/CMSIS/device; ../../../../../../firmware/N32L43x_std_periph_driver/inc; ../../../../bsp/inc; ..\..\..\..\..\..\firmware\n32l43x_algo_lib\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ALGO_Demo.bin
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\..\firmware\n32l43x_algo_lib\lib\n32l43x_aes.lib; ..\..\..\..\..\..\firmware\n32l43x_algo_lib\lib\n32l43x_rng.lib; ..\..\..\..\..\..\firmware\n32l43x_algo_lib\lib\n32l43x_algo_common.lib; ..\..\..\..\..\..\firmware\n32l43x_algo_lib\lib\n32l43x_des.lib; ..\..\..\..\..\..\firmware\n32l43x_algo_lib\lib\n32l43x_hash.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ALGO
    ../../../../../../firmware/n32l43x_algo_lib/lib/: n32l43x_aes.lib n32l43x_algo_common.lib n32l43x_des.lib n32l43x_hash.lib n32l43x_rng.lib
  group BSP
    ../../../../bsp/src/: log.c
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l43x.c
  group FWLB
    ../../../../../../firmware/n32l43x_std_periph_driver/src/: misc.c n32l43x_flash.c n32l43x_gpio.c n32l43x_rcc.c n32l43x_usart.c
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l43x_EWARM.s
  group USER
    ../src/: main.c n32l43x_it.c
